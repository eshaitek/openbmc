SRC_URI_raspberrypi4 := "git://github.com/eshaitek/pmci.git;protocol=ssh"
SRCREV_raspberrypi4 := "ada691a313b6abdfde72a700cebe76bb4ee960d1"
